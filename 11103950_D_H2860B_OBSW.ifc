Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2019-09-30T10:34:39
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170419_0315(x64) - Exporter 17.0.1128.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Sep 30 10:34:39 2019 * Host: DEGTL09122 * Database: C:\Users\deschvi\AppData\Local\Temp\{0FE86A5B-EEA1-4176-9868-C67A8B24812A}\ifc * Database version: 5507 * Database creation date: Mon Sep 30 10:34:38 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Sep 30 10:34:38 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Sep 30 10:34:39 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 22286024_D_11103950_H2860B_OBSW, 11103950_D_H2860B_OBSW:22286024_D_11103950_H2860B_OBSW:205984
In: Level 1
Type - Classification: H7000B-60 (Uniformat); Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_OBSW, z_Miele_Connection_Electric, z_Miele_Design_Zinc_Steel
Pset_BuildingElementProxyCommon - Reference: 22286024_D_11103950_H2860B_OBSW
Pset_ManufacturerTypeInformation - Manufacturer: Miele
